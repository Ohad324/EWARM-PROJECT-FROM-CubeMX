<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Backup of MyApplication.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MyApplication.ewp</path>
    </project>
    <batchBuild />
</workspace>
