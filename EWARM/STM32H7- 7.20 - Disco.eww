<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32H747I-DISCO.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\RTOS-ST\USBD\USBD\EWARM\USBD.ewp</path>
    </project>
    <batchBuild />
</workspace>
