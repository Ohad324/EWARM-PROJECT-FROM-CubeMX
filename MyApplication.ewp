# IAR project MyApplication.ewp, settings and files
configuration MyApplication_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M4 ST STM32H747XI_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: MyApplication_CM4.hex
  ILINK.IlinkOutputFile: MyApplication_CM4.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MyApplication_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_PWR_DIRECT_SMPS_SUPPLY
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../CM7/LIBJPEG/App; ../CM7/LIBJPEG/Target; ../CM7/TouchGFX/App; ../CM7/TouchGFX/target/generated; ../CM7/TouchGFX/target; ../Drivers/BSP/Components/Common; ../Drivers/BSP/STM32H747I-Discovery; ../Utilities/JPEG; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/RTOS2/Include; ../Middlewares/Third_Party/LibJPEG/include; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: MyApplication_CM7.hex
  ILINK.IlinkOutputFile: MyApplication_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: freertos.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/CM7/LIBJPEG/App
    ../CM7/LIBJPEG/App/: libjpeg.c
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: STM32H7Instrumentation.cpp STM32TouchController.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: HardwareMJPEGDecoder.cpp OSWrappers.cpp STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
  group Drivers/BSP/STM32H747I-Discovery
    ../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery_bus.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sdram.c stm32h747i_discovery_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
