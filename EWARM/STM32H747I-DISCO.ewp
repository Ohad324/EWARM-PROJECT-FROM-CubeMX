# IAR project STM32H747I-DISCO.ewp, settings and files
configuration STM32H747I-DISCO_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M4 ST STM32H747XI_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H747xx; USE_BPP=24; USE_PWR_DIRECT_SMPS_SUPPLY; EI_PORTING_IAR
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ohad3240-project-1-iar-v3/model-parameters; ohad3240-project-1-iar-v3/tflite-model; ohad3240-project-1-iar-v3; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Include; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/Core/Include; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../CM4/Core/Inc
  OBJCOPY.OOCOutputFile: STM32H747I-DISCO_CM4.hex
  ILINK.IlinkOutputFile: STM32H747I-DISCO_CM4.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I-DISCO_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_BPP=24; USE_PWR_DIRECT_SMPS_SUPPLY; FLATBUFFERS_USE_STD_OPTIONAL=0; TF_LITE_STATIC_MEMORY; EI_CLASSIFIER_ALLOCATION_STATIC=1; WAKE_WORD_TEST=1; EIDSP_USE_CMSIS_DSP=0; EI_CLASSIFIER_TFLITE_ENABLE_CMSIS_NN=0; EI_PORTING_IAR; EI_PORTING_IAR=1
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../CM7/TouchGFX/App; ../CM7/TouchGFX/target/generated; ../CM7/TouchGFX/target; ../Drivers/BSP/Components/Common; ../Drivers/BSP/STM32H747I-Discovery; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Utilities/JPEG; ../CM7/Middlewares/ST/touchgfx/framework/include; ../Drivers/CMSIS/RTOS2/Include; ../CM7/LIBJPEG/App; ../CM7/TouchGFX/gui/include; ../Middlewares/Third_Party/LibJPEG/include; ../CM7/TouchGFX/generated/gui_generated/include; ../CM7/TouchGFX/generated/texts/include; ../CM7/TouchGFX/generated/fonts/include; ../CM7/TouchGFX/generated/images/include; ../Middlewares/Third_Party/LibJPEG; C:\TouchGFXProjects\MyApplication\CM7\LIBJPEG\App; C:\TouchGFXProjects\MyApplication\CM7\LIBJPEG\Target; C:\TouchGFXProjects\MyApplication\CM7\LIBJPEG\App; C:\TouchGFXProjects\MyApplication\CM7\LIBJPEG\Target; C:\TouchGFXProjects\MyApplication\EWARM; C:\TouchGFXProjects\MyApplication\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; C:\TouchGFXProjects\MyApplication\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; C:\TouchGFXProjects\MyApplication\Edge Impulse; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\classifier\inferencing_engines; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\classifier\postprocessing; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\CMSIS\Core\Include; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\CMSIS\DSP\Include; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\CMSIS\NN\Include; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\porting\iar; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\third_party\flatbuffers\include; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\third_party\flatbuffers\include; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\third_party\flatbuffers\include; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\third_party\ruy; C:\TouchGFXProjects\MyApplication\Edge Impulse\edge-impulse-sdk\third_party\flatbuffers\include\flatbuffers; ohad3240-project-1-iar-v3/model-parameters; ohad3240-project-1-iar-v3/tflite-model; ohad3240-project-1-iar-v3; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Include; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/Core/Include; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ../CM7/Core/Inc
  OBJCOPY.OOCOutputFile: STM32H747I-DISCO_CM7.hex
  ILINK.IlinkOutputFile: STM32H747I-DISCO_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM7.icf
  ILINK.IlinkAdditionalLibs: C:\TouchGFXProjects\MyApplication\CM7\Middlewares\ST\touchgfx\lib\core\cortex_m7\IAR9.x\touchgfx_core.a
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_BPP=24; USE_PWR_DIRECT_SMPS_SUPPLY; RELEASE_BUILD; EI_PORTING_IAR
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../CM7/TouchGFX/App; ../CM7/TouchGFX/target/generated; ../CM7/TouchGFX/target; ../Drivers/BSP/Components/Common; ../Drivers/BSP/STM32H747I-Discovery; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Utilities/JPEG; ../CM7/Middlewares/ST/touchgfx/framework/include; ../Drivers/CMSIS/RTOS2/Include; ../CM7/LIBJPEG/App; ../CM7/TouchGFX/gui/include; ../Middlewares/Third_Party/LibJPEG/include; ../CM7/TouchGFX/generated/gui_generated/include; ../CM7/TouchGFX/generated/texts/include; ../CM7/TouchGFX/generated/fonts/include; ../CM7/TouchGFX/generated/images/include; ../Middlewares/Third_Party/LibJPEG; C:\TouchGFXProjects\MyApplication\CM7\LIBJPEG\App; C:\TouchGFXProjects\MyApplication\CM7\LIBJPEG\Target; C:\TouchGFXProjects\MyApplication\CM7\LIBJPEG\App; C:\TouchGFXProjects\MyApplication\CM7\LIBJPEG\Target; C:\TouchGFXProjects\MyApplication\EWARM; C:\TouchGFXProjects\MyApplication\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; C:\TouchGFXProjects\MyApplication\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ohad3240-project-1-iar-v3/model-parameters; ohad3240-project-1-iar-v3/tflite-model; ohad3240-project-1-iar-v3; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Include; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/Core/Include; ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  AARM.AUserIncludes: ../CM7/Core/Inc
  OBJCOPY.OOCOutputFile: STM32H747I-DISCO_CM7.hex
  ILINK.IlinkOutputFile: STM32H747I-DISCO_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM7.icf
  ILINK.IlinkAdditionalLibs: as above
  group (top)
    ../Edge Impulse/IAR project connection to EI/: edge_impulse_gen.ipcf
    ../Edge Impulse/edge-impulse-sdk/third_party/flatbuffers/include/flatbuffers/: fb_stl_emulation.h
    ../Middlewares/Third_Party/FatFs/src/: ff.c ffsystem.c ffunicode.c
    ./: stm32h747xx_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group Application/EWARM/Tasks
    ../CM7/Core/Src/: command_handler.c rtos_trace.c rtt_log_task.c wake_word_test.cpp
  group Application/USBD
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
    ../CM7/Core/Src/: usb_msc.c usbd_conf.c usbd_desc.c usbd_storage.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: audio_sd.c ble_uart.c fault_handler_asm.s freertos.c jpeg_decoder.c main.c music_display_task.c SEGGER_RTT.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c voice_recorder.c
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: STM32H7Instrumentation.cpp STM32TouchController.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: HardwareMJPEGDecoder.cpp OSWrappers.cpp STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp
  group Docs
    ./: DFSDM variables.txt
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
  group Drivers/BSP/STM32H747I-Discovery
    ../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery_bus.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sdram.c stm32h747i_discovery_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../CM7/Core/Lib/: libPDMFilter_CM7_IAR_wc16.a
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
    ../Drivers/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal_dfsdm.h
  group GUI
    ../CM7/TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp CompressedFontCache.cpp CompressedUnmappedFontCache.cpp Font_NotoSansHebrew_Regular_20_4bpp_0.cpp Font_NotoSansHebrew_Regular_80_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_80_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_NotoSansHebrew_Regular_20_4bpp.cpp Kerning_NotoSansHebrew_Regular_80_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_80_4bpp.cpp Table_NotoSansHebrew_Regular_20_4bpp.cpp Table_NotoSansHebrew_Regular_80_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_80_4bpp.cpp
    ../CM7/TouchGFX/generated/images/src/: BitmapDatabase.cpp SVGDatabase.cpp
    ../CM7/TouchGFX/gui/src/common/: FrontendApplication.cpp
    ../CM7/TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../CM7/TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
    ../CM7/TouchGFX/gui/src/model/: Model.cpp
    ../CM7/TouchGFX/gui/src/music_screen/: MusicScreenPresenter.cpp MusicScreenView.cpp
    ../CM7/TouchGFX/generated/gui_generated/src/music_screen/: MusicScreenViewBase.cpp
    ../CM7/TouchGFX/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
    ../CM7/TouchGFX/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
    ../CM7/TouchGFX/gui/src/: VectorFontRendererImpl.cpp
  group LIBJPEG
    ../CM7/LIBJPEG/App/: libjpeg.c libjpeg.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ohad3240-project-1/edge-impulse-sdk/classifier
    ohad3240-project-1-iar-v3/edge-impulse-sdk/classifier/: ei_aligned_malloc.h ei_classifier_config.h ei_classifier_smooth.h ei_classifier_types.h ei_constants.h ei_data_normalization.h ei_model_types.h ei_nms.h ei_print_results.h ei_quantize.h ei_run_classifier.h ei_run_classifier_c.cpp ei_run_classifier_c.h ei_run_classifier_image.h ei_run_dsp.h ei_signal_with_axes.h ei_signal_with_range.h
  group ohad3240-project-1/edge-impulse-sdk/classifier/inferencing_engines
    ohad3240-project-1-iar-v3/edge-impulse-sdk/classifier/inferencing_engines/: akida.h anomaly.h aton.h ceva_npn.h drpai.h engines.h ethos_linux.h memryx.h nordic_axon.h onnx_tidl.h tensaiflow.h tensorrt.h tflite_eon.h tflite_full.h tflite_helper.h tflite_micro.h tflite_tidl.h vlm_connector.h
  group ohad3240-project-1/edge-impulse-sdk/classifier/postprocessing
    ohad3240-project-1-iar-v3/edge-impulse-sdk/classifier/postprocessing/: ei_object_counting.h ei_object_tracking.h ei_performance_calibration.h ei_postprocessing.h ei_postprocessing_ai_hub.h ei_postprocessing_common.h ei_postprocessing_thresholds.h ei_postprocessing_types.h
  group ohad3240-project-1/edge-impulse-sdk/classifier/postprocessing/alignment
    ohad3240-project-1-iar-v3/edge-impulse-sdk/classifier/postprocessing/alignment/: ei_alignment.hpp rectangular_lsap.hpp
  group ohad3240-project-1/edge-impulse-sdk/classifier/postprocessing/tinyEKF
    ohad3240-project-1-iar-v3/edge-impulse-sdk/classifier/postprocessing/tinyEKF/: tinyekf.hpp tinyekf_custom.h
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/Core/Include
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h mpu_armv7.h mpu_armv8.h pac_armv81.h pmu_armv8.h tz_context.h
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Include
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_sorting.h arm_vec_fft.h arm_vec_filtering.h arm_vec_math.h arm_vec_math_f16.h
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Include/dsp
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/BasicMathFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_and_u16.c arm_and_u32.c arm_and_u8.c arm_clip_f16.c arm_clip_f32.c arm_clip_q15.c arm_clip_q31.c arm_clip_q7.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_not_u16.c arm_not_u32.c arm_not_u8.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_or_u16.c arm_or_u32.c arm_or_u8.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c arm_xor_u16.c arm_xor_u32.c arm_xor_u8.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/BayesFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/BayesFunctions/: arm_gaussian_naive_bayes_predict_f16.c arm_gaussian_naive_bayes_predict_f32.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/CommonTables
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/ComplexMathFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f16.c arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f16.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f16.c arm_cmplx_mag_f32.c arm_cmplx_mag_f64.c arm_cmplx_mag_fast_q15.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f16.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_f64.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f16.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_f64.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f16.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/ControllerFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/DistanceFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/DistanceFunctions/: arm_boolean_distance.c arm_boolean_distance_template.h arm_braycurtis_distance_f16.c arm_braycurtis_distance_f32.c arm_canberra_distance_f16.c arm_canberra_distance_f32.c arm_chebyshev_distance_f16.c arm_chebyshev_distance_f32.c arm_chebyshev_distance_f64.c arm_cityblock_distance_f16.c arm_cityblock_distance_f32.c arm_cityblock_distance_f64.c arm_correlation_distance_f16.c arm_correlation_distance_f32.c arm_cosine_distance_f16.c arm_cosine_distance_f32.c arm_cosine_distance_f64.c arm_dice_distance.c arm_euclidean_distance_f16.c arm_euclidean_distance_f32.c arm_euclidean_distance_f64.c arm_hamming_distance.c arm_jaccard_distance.c arm_jensenshannon_distance_f16.c arm_jensenshannon_distance_f32.c arm_kulsinski_distance.c arm_minkowski_distance_f16.c arm_minkowski_distance_f32.c arm_rogerstanimoto_distance.c arm_russellrao_distance.c arm_sokalmichener_distance.c arm_sokalsneath_distance.c arm_yule_distance.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/FastMathFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/FastMathFunctions/: arm_atan2_f16.c arm_atan2_f32.c arm_atan2_q15.c arm_atan2_q31.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_divide_q15.c arm_divide_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/FilteringFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f16.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f16.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f16.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f16.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f16.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f16.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q15.c arm_conv_opt_q7.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_partial_q7.c arm_conv_q15.c arm_conv_q31.c arm_conv_q7.c arm_correlate_f16.c arm_correlate_f32.c arm_correlate_f64.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q15.c arm_correlate_opt_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_q7.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f16.c arm_fir_f32.c arm_fir_f64.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f16.c arm_fir_init_f32.c arm_fir_init_f64.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_init_q7.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q15.c arm_fir_q31.c arm_fir_q7.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_init_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_fir_sparse_q7.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_levinson_durbin_f16.c arm_levinson_durbin_f32.c arm_levinson_durbin_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/InterpolationFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/InterpolationFunctions/: arm_bilinear_interp_f16.c arm_bilinear_interp_f32.c arm_bilinear_interp_q15.c arm_bilinear_interp_q31.c arm_bilinear_interp_q7.c arm_linear_interp_f16.c arm_linear_interp_f32.c arm_linear_interp_q15.c arm_linear_interp_q31.c arm_linear_interp_q7.c arm_spline_interp_f32.c arm_spline_interp_init_f32.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/MatrixFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/MatrixFunctions/: arm_householder_f16.c arm_householder_f32.c arm_householder_f64.c arm_mat_add_f16.c arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cholesky_f16.c arm_mat_cholesky_f32.c arm_mat_cholesky_f64.c arm_mat_cmplx_mult_f16.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_cmplx_trans_f16.c arm_mat_cmplx_trans_f32.c arm_mat_cmplx_trans_q15.c arm_mat_cmplx_trans_q31.c arm_mat_init_f16.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f16.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_ldlt_f32.c arm_mat_ldlt_f64.c arm_mat_mult_f16.c arm_mat_mult_f32.c arm_mat_mult_f64.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_opt_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_q7.c arm_mat_qr_f16.c arm_mat_qr_f32.c arm_mat_qr_f64.c arm_mat_scale_f16.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_solve_lower_triangular_f16.c arm_mat_solve_lower_triangular_f32.c arm_mat_solve_lower_triangular_f64.c arm_mat_solve_upper_triangular_f16.c arm_mat_solve_upper_triangular_f32.c arm_mat_solve_upper_triangular_f64.c arm_mat_sub_f16.c arm_mat_sub_f32.c arm_mat_sub_f64.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f16.c arm_mat_trans_f32.c arm_mat_trans_f64.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_q7.c arm_mat_vec_mult_f16.c arm_mat_vec_mult_f32.c arm_mat_vec_mult_q15.c arm_mat_vec_mult_q31.c arm_mat_vec_mult_q7.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/QuaternionMathFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/QuaternionMathFunctions/: arm_quaternion2rotation_f32.c arm_quaternion_conjugate_f32.c arm_quaternion_inverse_f32.c arm_quaternion_norm_f32.c arm_quaternion_normalize_f32.c arm_quaternion_product_f32.c arm_quaternion_product_single_f32.c arm_rotation2quaternion_f32.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/StatisticsFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/StatisticsFunctions/: arm_absmax_f16.c arm_absmax_f32.c arm_absmax_f64.c arm_absmax_no_idx_f16.c arm_absmax_no_idx_f32.c arm_absmax_no_idx_f64.c arm_absmax_no_idx_q15.c arm_absmax_no_idx_q31.c arm_absmax_no_idx_q7.c arm_absmax_q15.c arm_absmax_q31.c arm_absmax_q7.c arm_absmin_f16.c arm_absmin_f32.c arm_absmin_f64.c arm_absmin_no_idx_f16.c arm_absmin_no_idx_f32.c arm_absmin_no_idx_f64.c arm_absmin_no_idx_q15.c arm_absmin_no_idx_q31.c arm_absmin_no_idx_q7.c arm_absmin_q15.c arm_absmin_q31.c arm_absmin_q7.c arm_accumulate_f16.c arm_accumulate_f32.c arm_accumulate_f64.c arm_entropy_f16.c arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f16.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f16.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f16.c arm_logsumexp_f32.c arm_max_f16.c arm_max_f32.c arm_max_f64.c arm_max_no_idx_f16.c arm_max_no_idx_f32.c arm_max_no_idx_f64.c arm_max_no_idx_q15.c arm_max_no_idx_q31.c arm_max_no_idx_q7.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f16.c arm_mean_f32.c arm_mean_f64.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f16.c arm_min_f32.c arm_min_f64.c arm_min_no_idx_f16.c arm_min_no_idx_f32.c arm_min_no_idx_f64.c arm_min_no_idx_q15.c arm_min_no_idx_q31.c arm_min_no_idx_q7.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_mse_f16.c arm_mse_f32.c arm_mse_f64.c arm_mse_q15.c arm_mse_q31.c arm_mse_q7.c arm_power_f16.c arm_power_f32.c arm_power_f64.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f16.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f16.c arm_std_f32.c arm_std_f64.c arm_std_q15.c arm_std_q31.c arm_var_f16.c arm_var_f32.c arm_var_f64.c arm_var_q15.c arm_var_q31.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/SupportFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/SupportFunctions/: arm_barycenter_f16.c arm_barycenter_f32.c arm_bitonic_sort_f32.c arm_bubble_sort_f32.c arm_copy_f16.c arm_copy_f32.c arm_copy_f64.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_f16_to_float.c arm_f16_to_q15.c arm_fill_f16.c arm_fill_f32.c arm_fill_f64.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_f16.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_heap_sort_f32.c arm_insertion_sort_f32.c arm_merge_sort_f32.c arm_merge_sort_init_f32.c arm_q15_to_f16.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_quick_sort_f32.c arm_selection_sort_f32.c arm_sort_f32.c arm_sort_init_f32.c arm_weighted_sum_f16.c arm_weighted_sum_f32.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/SVMFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/SVMFunctions/: arm_svm_linear_init_f16.c arm_svm_linear_init_f32.c arm_svm_linear_predict_f16.c arm_svm_linear_predict_f32.c arm_svm_polynomial_init_f16.c arm_svm_polynomial_init_f32.c arm_svm_polynomial_predict_f16.c arm_svm_polynomial_predict_f32.c arm_svm_rbf_init_f16.c arm_svm_rbf_init_f32.c arm_svm_rbf_predict_f16.c arm_svm_rbf_predict_f32.c arm_svm_sigmoid_init_f16.c arm_svm_sigmoid_init_f32.c arm_svm_sigmoid_predict_f16.c arm_svm_sigmoid_predict_f32.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/DSP/Source/TransformFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_bitreversal_f16.c arm_cfft_f16.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f16.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f16.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f16.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f16.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f16.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_mfcc_f16.c arm_mfcc_f32.c arm_mfcc_init_f16.c arm_mfcc_init_f32.c arm_mfcc_init_q15.c arm_mfcc_init_q31.c arm_mfcc_q15.c arm_mfcc_q31.c arm_rfft_f32.c arm_rfft_fast_f16.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f16.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Include
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/ActivationFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/BasicMathFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s8.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/ConcatenationFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/ConvolutionFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_fast_s16.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_wrapper_s16.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_fast_s16.c arm_depthwise_conv_s16.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s16.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_s8.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/FullyConnectedFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s16.c arm_fully_connected_s8.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/NNSupportFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/PoolingFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s16.c arm_max_pool_s8.c arm_pool_q7_HWC.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/ReshapeFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/SoftmaxFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s16.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group ohad3240-project-1/edge-impulse-sdk/CMSIS/NN/Source/SVDFunctions
    ohad3240-project-1-iar-v3/edge-impulse-sdk/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c
  group ohad3240-project-1/edge-impulse-sdk/dsp
    ohad3240-project-1-iar-v3/edge-impulse-sdk/dsp/: config.hpp ei_alloc.h ei_dsp_handle.h ei_eeg.hpp ei_flatten.h ei_hr.hpp ei_profiler.h ei_utils.h ei_vector.h memory.cpp memory.hpp numpy.hpp numpy_types.h returntypes.h returntypes.hpp
  group ohad3240-project-1/edge-impulse-sdk/dsp/dct
    ohad3240-project-1-iar-v3/edge-impulse-sdk/dsp/dct/: fast-dct-fft.cpp fast-dct-fft.h
  group ohad3240-project-1/edge-impulse-sdk/dsp/dsp_engines
    ohad3240-project-1-iar-v3/edge-impulse-sdk/dsp/dsp_engines/: ei_arm_cmsis_dsp.h ei_ceva_dsp.h ei_ceva_dsp_fixed.h ei_cmsis_numpy.hpp ei_esp_dsp.h ei_no_hw_dsp.h
  group ohad3240-project-1/edge-impulse-sdk/dsp/image
    ohad3240-project-1-iar-v3/edge-impulse-sdk/dsp/image/: image.hpp processing.cpp processing.hpp
  group ohad3240-project-1/edge-impulse-sdk/dsp/kissfft
    ohad3240-project-1-iar-v3/edge-impulse-sdk/dsp/kissfft/: _kiss_fft_guts.h kiss_fft.cpp kiss_fft.h kiss_fftr.cpp kiss_fftr.h kissfft.h
  group ohad3240-project-1/edge-impulse-sdk/dsp/spectral
    ohad3240-project-1-iar-v3/edge-impulse-sdk/dsp/spectral/: feature.hpp filters.hpp fir_filter.hpp processing.hpp signal.hpp spectral.hpp wavelet.hpp wavelet_coeff.hpp
  group ohad3240-project-1/edge-impulse-sdk/dsp/speechpy
    ohad3240-project-1-iar-v3/edge-impulse-sdk/dsp/speechpy/: feature.hpp functions.hpp processing.hpp speechpy.hpp
  group ohad3240-project-1/edge-impulse-sdk/porting
    ohad3240-project-1-iar-v3/edge-impulse-sdk/porting/: ei_classifier_porting.h ei_logging.h
  group ohad3240-project-1/edge-impulse-sdk/porting/iar
    ohad3240-project-1-iar-v3/edge-impulse-sdk/porting/iar/: debug_log.cpp ei_classifier_porting.cpp
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/: builtin_op_data.h builtin_ops.h context_util.h portable_type_to_tflitetype.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/c
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.c common.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/core/api
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/core/api/: common.cc error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h tensor_utils.cc tensor_utils.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/core/c
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/core/c/: builtin_op_data.h c_api_types.h common.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/kernels
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/kernels/: kernel_util.h kernel_util_lite.cc op_macros.h padding.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/kernels/custom
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/kernels/custom/: tree_ensemble_classifier.cc tree_ensemble_classifier.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/kernels/internal
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.cc portable_tensor_utils.h quantization_util.cc quantization_util.h reduce_common.h reference_portable_tensor_utils.cc reference_portable_tensor_utils.h reference_portable_tensor_utils_impl.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h tensor_utils.cc types.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/kernels/internal/optimized
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/kernels/internal/reference
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_matmul.h batch_to_space_nd.h binary_function.h broadcast_args.h broadcast_to.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h div.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h lstm_cell.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h scatter_nd.h select.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/kernels/internal/reference/integer_ops
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/micro
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/micro/: all_ops_resolver.cc all_ops_resolver.h compatibility.h debug_log.h fake_micro_context.cc fake_micro_context.h flatbuffer_conversions_bridge.cc flatbuffer_conversions_bridge.h flatbuffer_utils.cc flatbuffer_utils.h ibuffer_allocator.h memory_helpers.cc memory_helpers.h micro_allocation_info.cc micro_allocation_info.h micro_allocator.cc micro_allocator.h micro_arena_constants.h micro_context.cc micro_context.h micro_error_reporter.cc micro_error_reporter.h micro_graph.cc micro_graph.h micro_interpreter.cc micro_interpreter.h micro_log.cc micro_log.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cc micro_profiler.h micro_profiler_interface.h micro_resource_variable.cc micro_resource_variable.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h mock_micro_graph.cc mock_micro_graph.h non_persistent_arena_buffer_allocator.cc non_persistent_arena_buffer_allocator.h op_resolver_bridge.cc op_resolver_bridge.h persistent_arena_buffer_allocator.cc persistent_arena_buffer_allocator.h recording_micro_allocator.cc recording_micro_allocator.h recording_micro_interpreter.h recording_single_arena_buffer_allocator.cc recording_single_arena_buffer_allocator.h schema_utils.cc single_arena_buffer_allocator.cc single_arena_buffer_allocator.h system_setup.cc system_setup.h test_helper_custom_ops.cc test_helper_custom_ops.h test_helpers.cc test_helpers.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/micro/kernels
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/micro/kernels/: activation_utils.h activations.cc activations.h activations_common.cc add.cc add.h add_common.cc add_n.cc arg_min_max.cc assign_variable.cc batch_matmul.cc batch_to_space_nd.cc broadcast_args.cc broadcast_to.cc call_once.cc cast.cc ceil.cc circular_buffer.cc circular_buffer.h circular_buffer_common.cc circular_buffer_flexbuffers_generated_data.h comparisons.cc complex_abs.cc concatenation.cc conv.cc conv.h conv_common.cc conv_test.h cumsum.cc depth_to_space.cc depthwise_conv.cc depthwise_conv.h depthwise_conv_common.cc dequantize.cc dequantize.h dequantize_common.cc detection_postprocess.cc detection_postprocess_flexbuffers_generated_data.h div.cc elementwise.cc elu.cc ethosu.cc ethosu.h exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc fully_connected.cc fully_connected.h fully_connected_common.cc gather.cc gather_nd.cc hard_swish.cc hard_swish.h hard_swish_common.cc if.cc kernel_runner.cc kernel_runner.h kernel_util.h kernel_util_micro.cc l2_pool_2d.cc l2norm.cc leaky_relu.cc leaky_relu.h leaky_relu_common.cc log_softmax.cc logical.cc logical.h logical_common.cc logistic.cc logistic.h logistic_common.cc lstm_eval.cc lstm_eval.h lstm_eval_test.h lstm_shared.h maximum_minimum.cc micro_ops.h micro_tensor_utils.cc micro_tensor_utils.h mirror_pad.cc mli_function_specializations.h mli_interface.cc mli_interface.h mli_slicers.cc mli_slicers.h mli_tf_utils.h mul.cc mul.h mul_common.cc neg.cc pack.cc pad.cc pad.h pooling.cc pooling.h pooling_common.cc prelu.cc prelu.h prelu_common.cc quantize.cc quantize.h quantize_common.cc read_variable.cc real.cc reduce.cc reduce.h reduce_common.cc reshape.cc resize_bilinear.cc resize_nearest_neighbor.cc rfft2d.cc round.cc scatter_nd.cc scratch_buf_mgr.cc scratch_buf_mgr.h scratch_buffers.cc scratch_buffers.h select.cc shape.cc slice.cc softmax.cc softmax.h softmax_common.cc space_to_batch_nd.cc space_to_depth.cc split.cc split_v.cc squared_difference.cc squeeze.cc strided_slice.cc sub.cc sub.h sub_common.cc svdf.cc svdf.h svdf_common.cc tanh.cc tile.cc topk_v2.cc transpose.cc transpose_conv.cc tree_ensemble_classifier.cc tree_ensemble_classifier.h unidirectional_sequence_lstm.cc unpack.cc var_handle.cc while.cc zeros_like.cc
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/micro/memory_planner
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.cc non_persistent_buffer_planner_shim.h
  group ohad3240-project-1/edge-impulse-sdk/tensorflow/lite/schema
    ohad3240-project-1-iar-v3/edge-impulse-sdk/tensorflow/lite/schema/: schema_generated.h schema_generated_full.h schema_utils.h
  group ohad3240-project-1/edge-impulse-sdk/third_party/arc_mli_package/include
    ohad3240-project-1-iar-v3/edge-impulse-sdk/third_party/arc_mli_package/include/: mli_api.h mli_config.h mli_types.h
  group ohad3240-project-1/edge-impulse-sdk/third_party/arc_mli_package/include/api
    ohad3240-project-1-iar-v3/edge-impulse-sdk/third_party/arc_mli_package/include/api/: mli_helpers_api.h mli_kernels_api.h mli_krn_avepool_spec_api.h mli_krn_conv2d_spec_api.h mli_krn_depthwise_conv2d_spec_api.h mli_krn_maxpool_spec_api.h mli_mov_api.h
  group ohad3240-project-1/edge-impulse-sdk/third_party/flatbuffers/include/flatbuffers
    ohad3240-project-1-iar-v3/edge-impulse-sdk/third_party/flatbuffers/include/flatbuffers/: fb_allocator.h fb_array.h fb_base.h fb_buffer.h fb_buffer_ref.h fb_default_allocator.h fb_detached_buffer.h fb_flatbuffer_builder.h fb_stl_emulation.h fb_string.h fb_struct.h fb_table.h fb_util.h fb_vector.h fb_vector_downward.h fb_verifier.h flatbuffers.h flexbuffers.h
  group ohad3240-project-1/edge-impulse-sdk/third_party/gemmlowp/fixedpoint
    ohad3240-project-1-iar-v3/edge-impulse-sdk/third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group ohad3240-project-1/edge-impulse-sdk/third_party/gemmlowp/internal
    ohad3240-project-1-iar-v3/edge-impulse-sdk/third_party/gemmlowp/internal/: detect_platform.h
  group ohad3240-project-1/edge-impulse-sdk/third_party/incbin
    ohad3240-project-1-iar-v3/edge-impulse-sdk/third_party/incbin/: incbin.h
  group ohad3240-project-1/edge-impulse-sdk/third_party/ruy/ruy/profiler
    ohad3240-project-1-iar-v3/edge-impulse-sdk/third_party/ruy/ruy/profiler/: instrumentation.h
  group ohad3240-project-1/model-parameters
    ohad3240-project-1-iar-v3/model-parameters/: model_metadata.h model_variables.h
  group ohad3240-project-1/tflite-model
    ohad3240-project-1-iar-v3/tflite-model/: tflite_learn_985318_3_compiled.cpp tflite_learn_985318_3_compiled.h trained_model_ops_define.h
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
